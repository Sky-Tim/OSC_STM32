# Keil uVision project STM32示波器+GUI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-FLASHLED +hex
  c flags: Optim=2 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\CM3;.\APP;.\uCOS-II\Ports;.\uCOS-II\Source;.\startup;.\GUI;.\GUI_X;.\GUI\GUI.H;.\GUI\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: main.c stm32f10x_it.c usart1.c delay v2.0.c pincfg.c adc.c dac v2.0.c EXTI.c indkey.c iwdg.c oscilloscope.c timer.c tft_api.c tft_drive.c tsc2046.c
    ./FWlib/SRC/: misc.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c
  group CMSYS
    ./CM3/: core_cm3.c system_stm32f10x.c
  group APP
    ./APP/: app.c task_gui.c task_main.c task_rtc.c task_sd.c task_touchscreen.c
  group uCOS-II\Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ./uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group GUI_X
    ./GUI_X/: GUI_X_Touch.c GUI_X_uCOS.c
    ./GUI/LCDDriver/: LCD_GUI_Interface.c
  group GUI_Config
    ./GUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group GUI
    ./GUI/: uCGUI_Lib.lib
